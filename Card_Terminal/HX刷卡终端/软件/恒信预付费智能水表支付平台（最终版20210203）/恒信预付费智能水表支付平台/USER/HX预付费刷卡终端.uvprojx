# Keil uVision project HX预付费刷卡终端.uvprojx, settings and files
target 刷卡终端平台 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HX预付费刷卡终端 +hex
  c flags: v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\INTERFACE\inc;..\CORE;..\FWlib\inc;..\SYSTEM\inc;..\HARDWARE\inc;..\Utils\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HARDWARE
    ../HARDWARE/src/: XFS.c M6311.c AT24C02.c Timer_Deal.c HDMI_T050.c CardInfoDeal.c Card24_Config.c Card42_Config.c Card57_Config.c
  group INTERFACE
    ../INTERFACE/src/: sys.c BSP_Config.c
  group USER
    ./: main.c
    ../SYSTEM/src/: stm32f10x_it.c
  group CORE
    ../CORE/: core_cm3.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_iwdg.c
  group SYSTEM
    ../SYSTEM/src/: IWDG.c systick.c IIC_Card.c Uart_XFS.c IIC_24C02.c String_Get.c Uart_HDMI.c Timer_Heart.c Usart_M6311.c system_stm32f10x.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group Utils
    ../Utils/src/: utils.c
  group readme
    ../readme/: readme.txt
