# Keil uVision project HQ预付费刷卡终端.uvprojx, settings and files
target 刷卡终端平台 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HQ预付费刷卡终端 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\INTERFACE\inc;..\CORE\inc;..\FWlib\inc;..\SYSTEM\inc;..\Utils\inc;..\HARDWARE\inc;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../SYSTEM/src/: stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/src/: sys.c systick.c IIC_24C02.c Timer_Heart.c String_Config.c Usart3_HDMI.c Usart2_PC.c Usart1_M6312.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/src/: M6312.c AT24C02.c USB_Config.c PC_Config.c PAM8406_Config.c HDMI_T050.c Timer_Deal.c CardInfoDeal.c HXCard_Config.c SCCard_Config.c
  group INTERFACE
    ../INTERFACE/src/: BSP_Config.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_md.s
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group CORE
    ../CORE/src/: core_cm3.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group Utils
    ../Utils/src/: utils.c
  group readme
    ../readme/: readme.txt
